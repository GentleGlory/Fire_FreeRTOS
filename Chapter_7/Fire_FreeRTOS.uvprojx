# Keil uVision project Fire_FreeRTOS.uvprojx, settings and files
target Target_1 (6230000::V6.23::ARMCLANG)
  device: ARMCM4 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: Fire_FreeRTOS
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\freertos\include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group user
    ./user/: main.c
  group doc
    ./doc/: readm.txt
  group freertos
    ./freertos/: list.c task.c
    ./freertos/include/: list.h FreeRTOS.h FreeRTOSConfig.h portable.h portmacro.h task.h projdefs.h
    ./freertos/portable/RVDS/ARM_CM4/: port.c
software components: CMSIS:CORE 6.1.0, Device:Startup 1.2.2
